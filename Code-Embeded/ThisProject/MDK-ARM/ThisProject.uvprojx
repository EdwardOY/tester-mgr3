# Keil uVision project ThisProject.uvprojx, settings and files
target ThisProject (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32L496VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2003FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: ThisProject +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32L496xx,THIS_PCR=_MCU_STM32_
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;../project-conf;../../ThisProject
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Application/User/Core
    ../Core/Src/: main_exe.c stm32l4xx_it_exe.c gpio.c spi.c usart.c main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group ThisProject/project-conf
    ../project-conf/: convert_def.h convert_path.h ThisProj_Conf.h ThisProj_Def.h ThisProj_Glb.c ThisProj_Glb.h
  group ThisProject/psp/board/atk-pdr496ve
    ../psp/board/atk-pdr496ve/: sample_led.c sample_led.h
  group ThisProject/psp/resource
    ../psp/resource/: res_gpio.c res_gpio.h res_uart.c res_uart.h
  group ThisProject/psp/middw/armfly
    ../psp/middw/Pack-Armfly/blink/: bsp_key.c bsp_key.h sample_keys_afl.c sample_keys_afl.h
  group ThisProject/psp/middw/Pack-ATK
    ../psp/middw/Pack-ATK/BSP/BEEP/: beep.c beep.h
  group ThisProject/psp/middw/cmbacktace
    ../psp/middw/CmBacktrace/: cm_backtrace.c sample_cmbt_app.h sample_cmbt_app.c cmb_cfg.h cmb_def.h cmb_fault.S
    ../psp/middw/CmBacktrace/Languages/zh-CN/: cmb_zh_CN_UTF8.h cmb_zh_CN.h
  group ThisProject/psp/prp-shell
    ../psp/prp-shell/: shell_gpio.c shell_gpio.h shell_uart.c shell_uart.h
  group ThisProject/psp/utility
    ../psp/utility/: types.h utility_def.c utility_def.h
  group ThisProject/psp/ProcessingDevice/stm32l496
    ../psp/ProcessingDevice/stm32l4xx/: sys_stm32l496ve.c sys_stm32l496ve.h
    ../psp/ProcessingDevice/: systick.c systick.h
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
software components: CMSIS:CORE 4.3.0
